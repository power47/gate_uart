# Keil uVision project gate_uart.uvprojx, settings and files
target gate_uart (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\api_uart;..\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group api_uart
    ../api_uart/: api_uart.c
  group main
    ./../src/: init.c buffer.c main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
